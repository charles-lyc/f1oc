# Repository charles-lyc/f1oc

File README.md:

# f1oc
A tiny STM32F1 based FOC controller 基于STM32F1的无刷控制器

## KiCad design hardware/f1oc/f1oc.kicad_pcb

Parts:
C1, C4, C7, C18, C19, C20, C21: 0.1uF; C_0603_1608Metric
C2, C3: 20pF; C_0603_1608Metric
C5: 10uF; C_1210_3225Metric
C6, C11, C17: X5R CERAMIC 16V 0.1uF; C_0603_1608Metric
C8: X5R CERAMIC 47nF; C_0603_1608Metric
C9: 50V 0.1uF; C_0603_1608Metric
C10: X5R CERAMIC 16V 1uF; C_0603_1608Metric
C12: 63V 1uF; C_0603_1608Metric
C13: 22uF; C_1206_3216Metric
C14, C15, C16: 30pF; C_0603_1608Metric
D2: LED; LED_0603_1608Metric
J1, J3: Conn_01x04_Shielded; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
L1: 47uH; L_Chilisin_BMRx00060630
R1, R9, R10, R13, R15, R17: 10k; R_0603_1608Metric
R2, R4, R5, R6: 470; R_0603_1608Metric
R3, R11: 100; R_0603_1608Metric
R7: 100K; R_0603_1608Metric
R8: 10K; R_0603_1608Metric
R12, R14, R16: 1k; R_0603_1608Metric
RN1: R_Pack04; R_Array_Convex_4x0603
TP1: MOTOR_A; TestPoint_Pad_D1.0mm
TP2: MOTOR_B; TestPoint_Pad_D1.0mm
TP3: MOTOR_C; TestPoint_Pad_D1.0mm
TP4: CAN_H; TestPoint_Pad_D1.0mm
TP5: CAN_L; TestPoint_Pad_D1.0mm
TP6: VBATT+; TestPoint_Pad_D1.0mm
TP7: VBATT-; TestPoint_Pad_D1.0mm
U1: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U2: DRV8316CRRGFR; DRV8316C
U3: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U4: MT6701CT; SO-8_3.9x4.9mm_P1.27mm
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C4.1, C13.1, C18.1, C19.1, C20.1, C21.1, J1.1, J3.1, L1.2, R1.1, R17.2, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U2.3 (FB_BK), U3.3 (VCC)
+3.3VA: C6.1, C7.1, C11.1, U1.9 (VDDA), U2.25 (AVDD), U4.1 (VDD), U4.2 (MODE)
+8~24V: C5.1, C9.1, C10.2, C12.1, R7.2, TP6.1, U2.9 (VM), U2.10 (VM), U2.11 (VM)
/CAN_RX: U1.45 (PB8), U3.4 (R)
/CAN_TX: U1.46 (PB9), U3.1 (D)
/CS: U1.38 (PA15), U4.8 (Z)
/CS_DRV: RN1.8 (R1.2), U1.22 (PB11)
/CUR_A: C14.1, R4.2, U1.17 (PA7)
/CUR_B: C15.1, R5.2, U1.18 (PB0)
/CUR_C: C16.1, R6.2, U1.19 (PB1)
/DRV_OFF: U1.33 (PA12), U2.21 (DRVOFF)
/IN_HA: U1.31 (PA10), U2.27 (INHA)
/IN_HB: U1.30 (PA9), U2.29 (INHB)
/IN_HC: U1.29 (PA8), U2.31 (INHC)
/IN_LA: U1.28 (PB15), U2.28 (INLA)
/IN_LB: U1.27 (PB14), U2.30 (INLB)
/IN_LC: U1.26 (PB13), U2.32 (INLC)
/LED: D2.2 (A), U1.12 (PA2)
/MISO: RN1.5 (R4.2), U1.40 (PB4), U4.6 (A)
/MOSI: RN1.6 (R3.2), U1.41 (PB5)
/MOTOR_A: R9.2, TP1.1, U2.13 (OUTA), U2.14 (OUTA)
/MOTOR_B: R13.2, TP2.1, U2.16 (OUTB), U2.17 (OUTB)
/MOTOR_C: R15.2, TP3.1, U2.19 (OUTC), U2.20 (OUTC)
/SCK: RN1.7 (R2.2), U1.39 (PB3), U4.7 (B)
/SWCLK: J3.3, U1.37 (PA14)
/SWD: J3.2, U1.34 (PA13)
/SW_BK: L1.1, U2.5 (SW_BK)
/UART_RX: J1.2, R3.2
/UART_TX: J1.3, R11.2
/VOL_A: R9.1, R12.2, U1.13 (PA3)
/VOL_B: R13.1, R14.2, U1.14 (PA4)
/VOL_C: R15.1, R16.2, U1.15 (PA5)
/V_BATT: R7.1, R8.1, U1.16 (PA6)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, J1.4, J1.SH (Shield), J3.4, J3.SH (Shield), R8.2, R10.2, R12.1, R14.1, R16.1, TP7.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.44 (BOOT0), U1.47 (VSS), U2.2 (AGND), U2.4 (GND_BK), U2.12 (PGND), U2.15 (PGND), U2.18 (PGND), U2.26 (AGND), U2.41 (EPAD), U3.2 (GND), U3.8 (Rs), U4.4 (GND), Y1.2, Y1.4
unnamed: D2.1 (K), R10.1
unnamed: RN1.1 (R1.1), U2.36 (NSCS)
unnamed: RN1.2 (R2.1), U2.35 (SCLK)
unnamed: RN1.3 (R3.1), U2.34 (SDI)
unnamed: RN1.4 (R4.1), U2.33 (SDO)
unnamed: C1.1, R1.2, U1.7 (NRST)
unnamed: R11.1, U1.42 (PB6)
unnamed: R3.1, U1.43 (PB7)
unnamed: C2.1, U1.5 (PD0), Y1.1
unnamed: C3.1, U1.6 (PD1), Y1.3
unnamed: C10.1, U2.8 (CP)
unnamed: C8.2, U2.7 (CPH)
unnamed: C8.1, U2.6 (CPL)
unnamed: R17.1, U2.22 (NFAULT), U2.23 (NSLEEP)
unnamed: R4.1, U2.40 (SOA)
unnamed: R5.1, U2.39 (SOB)
unnamed: R6.1, U2.38 (SOC)
unnamed: C17.1, U2.37 (VREF/ILIM)
unnamed: R2.1, TP4.1, U3.7 (CANH)
unnamed: R2.2, TP5.1, U3.6 (CANL)

Notes on the sheet:
TIM1 ch1~3 分别对应C B A相的输出PWM

Board: 2 copper layers, 33.0 x 33.0 mm, 55 parts (13 on the bottom side), 54 nets.

File hardware/f1oc/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C18, C19, C20, C21, C4, C7",0603,7,0.1uF,
C10,0603,1,X5R CERAMIC 16V 1uF,
"C11, C17, C6",0603,3,X5R CERAMIC 16V 0.1uF,
C12,0603,1,63V 1uF,
C13,1206,1,22uF,
"C14, C15, C16",0603,3,30pF,
"C2, C3",0603,2,20pF,
C5,1210,1,10uF,
C8,0603,1,X5R CERAMIC 47nF,
C9,0603,1,50V 0.1uF,
D2,0603,1,LED,
"J1, J3",JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal,2,Conn_01x04_Shielded,
L1,L_Chilisin_BMRx00060630,1,47uH,
"R1, R10, R13, R15, R17, R8, R9",0603,7,10k,
"R11, R3",0603,2,100,
"R12, R14, R16",0603,3,1k,
"R2, R4, R5, R6",0603,4,470,
R7,0603,1,100K,
RN1,R_Array_Convex_4x0603,1,R_Pack04,
TP1,TestPoint_Pad_D1.0mm,1,MOTOR_A,
TP2,TestPoint_Pad_D1.0mm,1,MOTOR_B,
TP3,TestPoint_Pad_D1.0mm,1,MOTOR_C,
TP4,TestPoint_Pad_D1.0mm,1,CAN_H,
TP5,TestPoint_Pad_D1.0mm,1,CAN_L,
TP6,TestPoint_Pad_D1.0mm,1,VBATT+,
TP7,TestPoint_Pad_D1.0mm,1,VBATT-,
U1,LQFP-48_7x7mm_P0.5mm,1,STM32F103C8Tx,
U2,DRV8316C,1,DRV8316CRRGFR,
U3,SOIC-8_3.9x4.9mm_P1.27mm,1,SN65HVD230,
U4,SO-8_3.9x4.9mm_P1.27mm,1,MT6701CT,
Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,8MHz,

## Code that names these connections

File firmware/f1oc.ioc (part):

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Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F103C8Tx
PA10.Signal=S_TIM1_CH3
PA11.Signal=GPIO_Output
PA12.Signal=GPIO_Input
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.Signal=GPIO_Output
PA3.Signal=ADCx_IN3
PA4.Signal=ADCx_IN4
PA5.Signal=ADCx_IN5
PA6.Signal=ADCx_IN6
PA7.Signal=ADCx_IN7
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.Signal=ADCx_IN8
PB1.Signal=ADCx_IN9
PB11.Signal=GPIO_Output
PB13.Mode=Output Compare1 CH1 CH1N
PB13.Signal=TIM1_CH1N
PB14.Mode=Output Compare2 CH2 CH2N
PB14.Signal=TIM1_CH2N
PB15.Mode=Output Compare3 CH3 CH3N
PB15.Signal=TIM1_CH3N
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PB8.Mode=CAN_Activate
PB8.Signal=CAN_RX
PB9.Mode=CAN_Activate
PB9.Signal=CAN_TX
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2024-12-04 first commit, complete a v0.1 demo hardware.
2024-12-05 add .gitingore
2024-12-05 JLC pcb prototyping
